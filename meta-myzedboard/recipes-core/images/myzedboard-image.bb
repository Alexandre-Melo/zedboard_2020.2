SUMMARY = "MyZedboard image"
LICENSE = "MIT"
PR = "r1"

inherit core-image
inherit autologin

IMAGE_LINGUAS = " "

IMAGE_FSTYPES = "cpio.gz cpio.gz.u-boot"

#inherit image-repo-info