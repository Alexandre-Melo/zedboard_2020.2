FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-set-a-default-bootcmd-to-load-fat-image.ub.patch"

